# Repository Mmrliu-gooooood/smart-pen-codex

## KiCad design hardware/power14_single_feed_candidate/power_integrated_study.kicad_pcb

File hardware/power14_single_feed_candidate/README.md:

# 14×45 mm single-feed thermal-supply candidate

**NOFAB. JP1 remains OPEN / DNP. This is an isolated layout candidate, not a production release.**

## Authoritative files

Only `SINGLE_FEED_MANIFEST.json` lists current candidate evidence. Other copied files in this research directory (old `drc.rpt`, `erc.rpt`, `preview/`, `projection_check.json`, old `run_checks.sh`, routing experiments) are inherited baseline working material and are **not current verification or previews**. Do not publish this directory recursively. Use `run_single_feed_checks.sh` for this candidate.

The original frozen `hardware/power_integrated_layout_14x45` and its 104-file manifest remain unchanged. This candidate uses its schematic, rules, footprints, placements and BOM unchanged.

## Exact layout change

Removed seven **added thermal F.Cu VBUS tracks**, not original charger-core copper. Added three 0.30 mm F.Cu segments:

C1.1 (7.75, 4.80) → (8.10, 5.15) → (8.10, 5.825) → existing thermal via (7.50, 6.425), in mm.

Exact UUIDs are in `single_feed_delta.json`; actual geometry and whole-board preservation are checked in `single_feed_check.json`. All other tracks/vias and every footprint/pad/value/net/DNP are unchanged relative to the frozen integrated board. Filled polygons are regenerated and may differ; no claim that all copper fill is byte-identical.

This removes additional front-side connections to the J2/BQ charging trunk. The retained old wide charger trunk now carries the full conditional BQ load. The new feeder joins at C1's input pad under the ideal-pad model. The rest of the thermal network remains the previous routed network, including 0.15 mm segments, local loops and cross-layer paths. **This is not a complete replacement of every thermal trace with a 0.30 mm tree**, and does not independently qualify quiet/Kelvin returns.

## Fresh checks, 2026-10-28 UTC

- Native ERC: 0 errors, 0 warnings, `--exit-code-violations` enabled.
- Native DRC + schematic parity: 0 violations, 0 unconnected pads, 0 footprint errors; true process exit 0.
- All 25 multi-pad networks pass actual-contact/filled-island connectivity checks.
- Explicit source/delta checker preserves all baseline copper except the seven whitelisted additions; unique JP1 remains DNP and schematic source/rules are byte-identical.
- Normal Python and `python -O` produce equal resistor-network and delta-check output; safety decisions in the new delta checker use explicit exceptions, not asserts. This does not certify every inherited script fail-closed.
- Original frozen 104 file hashes remain unchanged.

## Conditional DC comparison

The independent analysis implementation is reused, adapted only for candidate path/source hash, in `reproduce_network_candidate.py`. This is a lumped network, not finite-element/current-rating signoff. Assumptions: 85°C copper, outer31.5µm/inner18µm, ideal zero-ohm pads/vias, no source/return/pad-spreading impedance, heating, dynamics or device models.

- Only BQ U1.13 = 1 A normalized load: old board added-thermal maximum 0.322809852 A/A; candidate maximum 6.8×10^-14 A/A (numerical zero). KCL and power conservation checked.
- Candidate J2→BQ trace drop 9.478628 mV/A; old parallel network 6.821066 mV/A. Increased drop is expected after removing the unintended parallel shortcut. It does not establish or violate a current rating by itself.
- Only U102.4 = hypothetical25mA: candidate drop 7.062865mV vs old7.046764mV. This load is a sensitivity case, not an actual specified IC worst-case current.
- 1 A is not USB current authorization. The PCB still requires USB startup, charging-current, copper/via/temperature and component qualification.

Do not subtract VBUS drop directly from comparator differential threshold margins. The previous independent report distinguishes 20°C recovery availability from 10°C/45°C inhibit safety. This layout change does not close reference/NTC leakage, differential ground shift, dynamic ramp, thermal coupling, assembly, cell or firmware safety gates. Never close JP1 on this evidence alone.

## Reproduction and dependencies

Run `bash run_single_feed_checks.sh`; installed KiCad9, `/usr/bin/python3` pcbnew and numpy are needed. Relative preserved-source dependencies are `../power_core_layout_candidate/power_core_NOFAB.kicad_pcb` and `../power_integrated_layout_14x45/` (frozen manifest). `make_single_feed.py` regenerates an alternate candidate with fresh track UUIDs and updates its delta manifest; do not run it on a frozen publication snapshot.

No power-up, physical measurement, manufacturer DFM, Gerber release, purchasing or remote publication was performed.

Notes on the sheet:
LAYOUT STUDY ONLY: two real offboard NTCs, no charge/fabrication approval.

Parts:
C1: 2.2uF 16V; C_0805_2012Metric
C2, C3, C4: 10uF 10V; C_0805_2012Metric
C5, C6: 22uF 6.3V; C_0805_2012Metric
J1: NTC WIRES / MPN TBD; WireLands_2_P2.5_AssemblyUnqualified
J2: VBUS IN; WireLands_2_P2.5_AssemblyUnqualified
J3: 3V3 OUT; WireLands_2_P2.5_AssemblyUnqualified
J4: PROTECTED PACK ONLY; WireLands_2_P2.5_AssemblyUnqualified
J5: MCU USB MODE / NO CE PORT; WireLands_Mode3_KeyGap_NOFAB
JP1: OPEN / DO NOT BRIDGE; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm; not fitted
L1: XFL4015-471MEC 0.47uH; Coilcraft_XFL4015_Official_NOFAB
R1: 8.66k 1%; R_0603_1608Metric
R2: 3.24k 1%; R_0603_1608Metric
R3: 68k 1%; R_0603_1608Metric
R4, R5: 100k; R_0603_1608Metric
R6: 10k 1%; R_0603_1608Metric
R7: 511k 1%; R_0603_1608Metric
R8: 91k 1%; R_0603_1608Metric
RT102: NTCLE100E3103GB0 / OFFBOARD CANDIDATE
U1: BQ24074RGTR; TI_RGT0016B_Official_NOFAB
U2: TPS63802DLAR; TI_DLA0010A_Official_NOFAB

Connections:
/core/3V3_AON: C5.1, C6.1, J3.1, R7.1, U2.6 (VOUT)
/core/CHARGE_DISABLE: JP1.1 (A), R6.2, U1.4 (~CE)
/core/CHG_ILIM: R2.1, U1.12 (ILIM)
/core/CHG_ISET: R1.1, U1.16 (ISET)
/core/CHG_TMR: R3.1, U1.14 (TMR)
/core/PACK_NTC: J1.1, RT102.1, U1.1 (TS)
/core/PACK_PLUS_PROTECTED: C2.1, J4.1, U1.2 (BAT), U1.3 (BAT)
/core/REG_FB: R7.2, R8.1, U2.4 (FB)
/core/SW_L1: L1.1, U2.9 (L1)
/core/SW_L2: L1.2, U2.7 (L2)
/core/SYS_RAW: C3.1, C4.1, U1.10 (OUT), U1.11 (OUT), U2.1 (EN), U2.10 (VIN)
/core/USB_EN1: J5.1, R4.1, U1.6 (EN1)
/core/USB_EN2: J5.2, R5.1, U1.5 (EN2)
CE_PERMISSION_INTERNAL: JP1.2 (B); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.2, J2.2, J3.2, J4.2, J5.3, R1.2, R2.2, R3.2, R4.2, R5.2, R8.2, RT102.2, U1.8 (VSS), U1.17 (VSS), U2.2 (MODE), U2.3 (AGND), U2.8 (GND); also elsewhere on the board
VBUS_5V: C1.1, J2.1, R6.1, U1.13 (IN); also elsewhere on the board

Notes on the sheet:
2026-10-28 重建稿 / REBUILT - NO FAB - 禁止投板与连接未批准电池
不是原件恢复；本次重新生成与检查。JP1保持开路，充电默认禁用；已核IC landpattern；完整BOM、电池、NTC与热设计未放行。
1 电池电源路径 / POWER PATH
2 常供电升降压 / BUCK-BOOST
J1: 外接真实NTC两线接口，型号/温度窗口/连接器待定。
GND = 保护后PACK_MINUS；禁止连接裸CELL_MINUS绕过保护。
3 专用GPIO接口 / 调试充电跳线
USB_EN1 -> MCU GPIO18；USB_EN2 -> GPIO21；禁止复用UART。
复位默认LOW/LOW=USB100；休眠/枚举/来源授权仍需系统验证。
JP1为物理开路跳线，未批准电池/NTC前禁止短接。
R1=8.66k: 91.12-113.73mA；R2=3.24k: 最坏536.23mA。
R2不是500mA硬上限；CE支路电流也必须计入USB总电流。
511k/91k -> 3.3077V标称；纹波/偏置/负载阶跃尚未测试。
COUT有效容量与电感饱和/DCR需按实际器件和布局核验。
14x45mm PCB候选；有效C、热、制造与线束尚未批准。
RELEASE BLOCKERS / 未放行项目
仅验证过的5V输入；USB-C/ESD/OVP在外部。
VBUS_5V / 3V3_AON / USB_EN1 / USB_EN2为统一逻辑网名。
充电电压容差、NTC故障与温度边界、保护电池待验证。
CE内部约285k下拉：JP1开路也有VBUS偏置电流。
JP1改为外部安全许可串联开路；绝不是直接接地许可。
转换器低压能力不等于正常电池放电截止；策略待定。
本次ERC仅检查连接，不批准电池充电或生产。
RT102: OFFBOARD CELL NTC #1 via J1 Independent from RT101; protected GND only. Candidate part, pack mounting NOT qualified.

Parts:
C101, C102, C103, C104, C105, C106: 100nF 16V; C_0603_1608Metric
C107: 4.7uF / effective0.1..10uF TBD; C_0805_2012Metric
J104: CELL NTC2 TWO WIRES; WireLands_2_P2.5_AssemblyUnqualified
R101: 200R 0.1% / total0.2%; R_0805_2012Metric
R102, R104, R109: 10k 0.1% / total0.2%; R_0805_2012Metric
R103: 34k 0.1% / total0.2%; R_0805_2012Metric
R105, R114: 100k 1%; R_0603_1608Metric
R106, R107: 1M 1%; R_0603_1608Metric
R110: 110k 0.1% / total0.2%; R_0805_2012Metric
R111, R113: 100k 0.1% / total0.2%; R_0805_2012Metric
R112: 255k 0.1% / total0.2%; R_0805_2012Metric
RT101: NTCLE100E3103GB0
U101: TPS3808G25DBVR; TI_DBV0006A_OfficialDerived_NOFAB
U102: TPS3899DL01DSER; TI_DSE0006A_SMDleft_ExposedDerived_NOFAB
U103, U104: TMUX1101DCKR; TI_DCK0005A_OfficialDerived_NOFAB
U105: TPS3700DDCR; TI_DDC0006A_OfficialDerived_NOFAB
U106: REF3425IDBVR; TI_DBV0006A_OfficialDerived_NOFAB

Connections:
/thermal/CE_MID: U103.1 (D), U104.2 (S)
/thermal/COLD_SENSE: R112.2, R113.1, U105.4 (INB-)
/thermal/HOT_SENSE: R110.2, R111.1, U105.3 (INA+)
/thermal/NTC_NODE: J104.1, R109.2, R110.1, R112.1, RT101.1
/thermal/REF_EXC: C107.1, R101.1, R103.1, R109.1, U106.5 (OUT_S), U106.6 (OUT_F)
/thermal/REF_SENSE_FAST: R103.2, R104.1, U102.5 (SENSE)
/thermal/REF_SENSE_SLOW: R101.2, R102.1, U101.5 (SENSE)
/thermal/REF_VALID: R105.2, R106.1, U101.1 (RESET_N), U102.6 (RESET_N), U104.4 (SEL)
/thermal/THERM_OK: R107.1, R114.2, U103.4 (SEL), U105.1 (OUTA), U105.6 (OUTB)
CE_PERMISSION_INTERNAL: U103.2 (S); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, J104.2, R102.2, R104.2, R106.2, R107.2, R111.2, R113.2, RT101.2, U101.2 (GND), U102.3 (GND), U103.3 (GND), U104.1 (D), U104.3 (GND), U105.2 (GND), U106.1 (GND_F), U106.2 (GND_S); also elsewhere on the board
VBUS_5V: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, R105.1, R114.1, U101.3 (MR_N), U101.6 (VDD), U102.4 (VDD), U103.5 (VDD), U104.5 (VDD), U105.5 (VDD), U106.3 (EN), U106.4 (IN); also elsewhere on the board

Notes on the sheet:
CE dual-SPST logic interlock candidate / NEW-REF-P0 / NOFAB
SYSTEM-P0: thermal R8 / JP1 removed; CORE JP1 is sole OPEN commissioning gate.
U101 CT deliberately open: 12-28ms release delay. U102 CTS/CTR open: conditional 50us max fault detect.
REF2.5V / conditional safety2.34-2.53V. 20-30C static permission tested; thermal lag and transients NOT approved.
LAYOUT STUDY ONLY: two real offboard NTCs, no charge/fabrication approval.
RT101 = OFFBOARD CELL NTC #2 / NOT PCB-MOUNTED BOM retained; independent two wires via J104. No pack qualification or thermal-bond approval.

Board: 4 copper layers, 14.0 x 45.0 mm, 50 parts (26 on the bottom side), 25 nets.

## KiCad design hardware/rf_feed_conditional_candidate/mainboard_revD.kicad_pcb

File hardware/rf_feed_conditional_candidate/README.md:

# 条件 RF 馈线候选 — 仅几何/连通证据，NOFAB

**不能据此生产整笔或声称射频通过。** 本目录不含射频实测、制造商下单确认或购买授权。

## 结果与身份

- 唯一候选：`mainboard_revD.kicad_pcb`，SHA256 `b39eb6319473eb29e7cc7644769d17bb64c872602a6cae6a041148aad75ef52d`。
- 基线：`source_before.kicad_pcb`，SHA256 `af7ea5488de178176dded49c9130ccca6c76334c7df96e80d869338406449714`，来自已冻结 `hardware/obsolete_track_cleanup`；未更改该源。
- 板外形仍 **12 × 101.5 mm**，没有向左/右扩宽；与数字团队其他宽度分支不可默认混合。
- ERC **0**；完整带 schematic-parity 的 DRC：**几何违规 0、未连 1（继承 USB_EN1）、缺封装 13（继承）**。退出码 **5** 正确保留；不能称整板 DRC 全通过。
- 实际全部焊盘连通分量：仅 RF_SIP、RF_ANT 从分离变连通，其他网络全部保持基线分量；GPIO45/46、CAM_SDA、电源与地未被断开。
- 独立的有限铜多边形检查：77 个 GND 焊盘形状为同一分量，六层天线净空中没有其他铜；不是只看飞线。
- 普通 Python 与 `-O` 的全网络和有限铜检查输出相同。上述是作者检查，不能冒称独立审查结果。

## 真实改动

精确 UUID、修改前后坐标/层/线宽都在 `all_net_audit.json`，`build_rf.py` 是可复现构建逻辑，不是对正在运行的其他候选直接写入的脚本。

1. R104 保留 **10k、F 面**，移到 `(3.5, 1.7)`，方向 0°。GPIO45 从新焊盘短接原 MCU 端路径；不用旧背面回折和两处不再必要的绑带过孔。GND 从新右焊盘接真实地过孔 `(4.1,1)`。没有翻到 B 面。
2. R105 不移动、不改值。保留 `R105.2 → (5.1,4) → (4.35,4.75) → (3,4.75) → (3,4.65) → GND via(2.8,4.45)` 的主回地。裁除该地过孔与地过孔 `(4.1,1)` 间冗长的顶层桥，**不是谎称原桥悬空**；通过真实地平面、全部 pad 分量和有限铜图验证回地仍闭合。
3. 裁除 R104 移位后失效的旧地分支，但保留 C103 地焊盘 `(1.05,6.25)` 到地 via `(1.05,5.3)` 的去耦回流。PICO 和所有供电去耦器件位置/焊盘不变。
4. CAM_SDA 低速信号过孔从 `(2.3,5.05)` 改到 `(2.65,5.25)`，只同步修改其 B.Cu、In2.Cu 两段端点；其余摄像头线不动。此举为 RF 的实际参考地避空让出余量，不是任意改网络。
5. C106/C107 改为 KiCad `Capacitor_SMD:C_0402_1005Metric` 条件封装，保持原 DNP、待调值、引脚网络和原理图实例对应。坐标分别 `(6.65,1.38)`、`(9.5,1.38)`，270°；RF 焊盘 y=0.9，GND 焊盘 y=1.86。L101 到 `(8.05,0.9)`，方向 0°，待选待调。
6. C106 地用新 **0.6/0.3 mm** 通孔 `(7.6,2.1)`；C107 地接已有 `(9.275,3)` 地通孔。所有层检查无新增通孔短路/间距问题。
7. 移除旧左端匹配区的 F.Cu 地覆铜；它不再服务移位后的电容，也不能让“非共面”模型线旁意外紧贴大片共面地。In1 地平面在天线入口延到 y=0，天线净空仍不得覆铜。

## 馈线、匹配和净空：不要把条件数字说成实测

依据官方公共模板 `JLC06081H-2116` 的条件计算：L1→L2 微带宽 **0.1814 mm**；另一备选 CPWG 是 **0.1707 mm / 地隙 0.2 mm**。本候选用前者，**没有把后者参数混用**。输入合同在 `stackup_contract_snapshot.json`；厂家尚未选定，订单叠层、材料/Dk、蚀刻公差、阻焊、阻抗券均未确认。CAD 原有 0.8 mm 厚度属性不是已批准的实际叠层；模板成品标称约 0.83±0.10 mm。制造前必须在最终集成工程落实完整叠层合同。

- RF 源端至 C106 的路径点、实际长度见 `route_proposal.json`；无 RF 换层/过孔。
- 匹配区位于 y>0 的有参考地区，不能把左侧匹配直接横穿 6.5 mm 辐射净空。
- **终端**仅沿 x=9.5 从 y=0 接到 AE101.1 的 y=−1.9：这是本候选的 **1.9 mm 无地过渡**，不是 50 Ω 微带，也不是 Johanson 官方规定的该长度。其图上的 1.9 mm 标注属于参考匹配区尺寸，不能偷换含义。
- 原生 all-layer 规则持续禁止整个 `x5.5..12,y−6.5..0` 区域中的覆铜、过孔；第二条带窄槽的规则禁止其余走线。窄槽只为这段 F.Cu RF_ANT 终端。有限铜检查额外禁止任何其他网络/焊盘侵入，不能把 CAD 窄槽当任意布线许可。
- AE101.2 仍为原理图 **NC 机械焊接端**，不是地。Johanson 2450AT18A0100001E Rev4 原生研究封装和角落净空不变。
- 实际填充 In1 铜覆盖所有有参考段的有限线宽（y=0 端帽的负 y 半圆计入终端过渡）。`reference_screen.json` 给逐段证据。额外 0.35 mm（约 3×0.1164 mm）侧向地包络是**本项目筛查假设**，非官方强制阈值；源端局部仍有微小包络缺口，天线入口包络必然进入无地区。
- `coplanar_proximity.json` 记录源端 C103/其地过孔附近约 0.31–0.325 mm 的同层地接近。**器件焊盘、源端逃线、匹配区及天线入口是非均匀过渡；不能声称整条线路已经严格 50 Ω。** 必须做电磁/厂商复核及 VNA/装壳调试。
- 当前外部网络仍是原设计的 π 占位，不是假装复制 Johanson 的 tee 参考网络。未照搬其评估板元件值；若厂家调试要求 tee，应先修改源图及布局再复核。当前待调/DNP 状态不等于射频硬件已经可工作。

## 检查和复现

使用 KiCad 9、`/usr/bin/python3` 的 pcbnew，以及本目录 `tools/`。源身份在构建前显式检查。

```sh
export XDG_CONFIG_HOME=/tmp/pen-rf-check/config
export XDG_CACHE_HOME=/tmp/pen-rf-check/cache
export XDG_DATA_HOME=/tmp/pen-rf-check/data
export KICAD9_FOOTPRINT_DIR=/usr/share/kicad/footprints
kicad-cli pcb drc --format json --schematic-parity --exit-code-violations -o /tmp/rf-drc.json mainboard_revD.kicad_pcb
/usr/bin/python3 audit_all_nets.py
/usr/bin/python3 check_finite_copper.py
/usr/bin/python3 check_rf_reference.py
/usr/bin/python3 check_coplanar_proximity.py
```

`build_rf.py` 只应复制到新研究目录后运行；它会生成新 UUID 和暂存板，不能用来覆盖本冻结交付。审查/合并应使用冻结 PCB 和明确差量，复核目标分支的全图、全部铜及实际板壳截面，而非只套检查计数。

拒绝过的方案：12 mm 板边 x≈0.25 的无足够返回地绕行；R104 原位翻 B 与 CAM_SDA 冲突；0603 匹配与原数字区碰撞；没有完整参考地的横穿天线净空。这些不是本目录的交付 PCB。

## 制造/产品仍待完成

- 合并其他主板修改后，完整 ERC/DRC/一致性与实际铜再查；EN1 和13个缺封装不能被此分支掩盖。
- 具体 RF 元件料号、0402额定/公差与可焊性、匹配拓扑、采购报价和单笔380元完整BOM仍未批准。
- 最终天线与电池、手握、笔夹/金属、线束、壳体材料和组装偏差一起测试；不能因净空二维合格就声称18mm外壳/射频合格。
- 去嵌/校准夹具、VNA S11、匹配调谐、BLE 全频段包错率/吞吐/距离、充电/书写时噪声及真实握姿测试；不伪造结果。
- 没有采购、上传、无线发射测试或制造放行。

## 一手资料

- [Johanson Rev4 数据表，尤其第2–3页](https://www.johansontechnology.com/docs/3827/Antenna-2450AT18A0100001E-Rev4.0.pdf)
- [JLCPCB 官方阻抗计算器](https://jlcpcb.com/pcb-impedance-calculator)；完整取证见仓库 `docs/research/stackup_qualification/`。
- [Espressif ESP32-S3 PCB RF指导](https://docs.espressif.com/projects/esp-hardware-design-guidelines/en/latest/esp32s3/pcb-layout-design.html#rf)
- [ESP32-S3-PICO-1数据表](https://documentation.espressif.com/esp32-s3-pico-1_datasheet_en.pdf)：SiP内部已有匹配，不能无辨别复制裸片匹配/开路stub。

Board: 6 copper layers, 12.0 x 101.5 mm, 78 parts (3 on the bottom side), 57 nets.

Parts:
AE101: 2450AT18A0100001E_STUDY_NOFAB; Johanson_2450AT18A0100001E_Rev4_Study_NOFAB
C101: 1u; C_0603_1608Metric
C102: 22u; C_0603_1608Metric
C103, C104, C105: 100n; C_0603_1608Metric
C106, C107: DNP RF_TUNE; C_0402_1005Metric
C201, C202, C203, C204, C205, C206, C207, C208: 100n X7R; C_0603_1608Metric
J106: POWER_CORE; PowerWireLands3_KeyGap_NOFAB
J107: CHARGER_MODE; ModeWireLands3_KeyGap_NOFAB
J108: SERVICE_EN_BOOT_GND; ServiceProbe3_NOFAB
JP201: DNP_IO_COMMISSION; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP202: DNP_SCCB_COMMISSION; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L101: RF_MATCH_TBD; L_0402_1005Metric
Q201: PMV30UN2; SOT-23
R101, R102, R103, R104, R105, R203, R206, R207: 10k 1%; R_0603_1608Metric
R106, R107, R108, R109, R202, R210, R211, R212, R213, R214, R215, R216, R218, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231, R232, R233, R234, R235, R237: 100k 1%; R_0603_1608Metric
R112, R113: 22R SI_TBD; R_0603_1608Metric
R201: 1k 1%; R_0603_1608Metric
R204: 100R 1%; R_0603_1608Metric
R205: 4.7k 1%; R_0603_1608Metric
R217: 100k 1%; R_0402_1005Metric
R236: 4.7k 1% RESET_CANDIDATE; R_0603_1608Metric
R240, R241, R242, R243: 10k 1% INITIAL_100kHz; R_0603_1608Metric
U101: ESP32-S3-PICO-1-N8R8; ESP32-S3-PICO-1_LGA57_7x7_P0.4_OfficialDerived_NOFAB
U201: SN74AXC8T245PWR; TSSOP-24_4.4x7.8mm_P0.65mm
U202, U203: SN74AXC4T245PWR; TSSOP-16_4.4x5mm_P0.65mm
U204: TCA9517DGKR; VSSOP-8_3x3mm_P0.65mm

Connections:
3V3_AON: C102.1, C103.1, C104.1, C105.1, C201.1, C203.1, C205.1, C207.1, J106.2, R101.2, R102.2, R103.2, R203.2, R240.2, R241.2, U101.2, U101.3, U101.20, U101.46, U101.55, U101.56, U201.1, U202.1, U203.1, U203.2, U203.3, U204.8
BOOT_N: J108.2, R102.1, U101.5
CAM_BUS_EN: JP202.1, R108.1, U101.37
CAM_D0: R210.1, U101.12, U201.3
CAM_D1: R211.1, U101.13, U201.4
CAM_D2: R212.1, U101.14, U201.5
CAM_D3: R213.1, U101.15, U201.6
CAM_D4: R214.1, U101.16, U201.7
CAM_D5: R215.1, U101.17, U201.8
CAM_D6: R216.1, U101.18, U201.9
CAM_D7: R217.1, U101.19, U201.10
CAM_HREF: R220.1, U101.23, U202.6
CAM_IO_EN: JP201.1, R107.1, U101.48
CAM_ISO_OE_N: Q201.3, R203.1, U201.22, U202.14, U202.15, U203.14, U203.15
CAM_PCLK: R218.1, U101.21, U202.4
CAM_PWDN_UART_RX: R223.1, U101.50, U203.6
CAM_PWR_EN: R106.1, U101.47
CAM_RESET_UART_TX: R222.1, U101.49, U203.5
CAM_SCL: R240.1, U101.44, U204.7
CAM_SDA: R241.1, U101.45, U204.6
CAM_VSYNC: R219.1, U101.22, U202.5
CAM_XCLK: R221.1, U101.43, U203.4
CHIP_EN: C101.1, J108.1, R101.1, U101.4
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, J106.3, J107.3, J108.3, Q201.2, R104.2, R105.2, R106.2, R107.2, R108.2, R109.2, R202.2, R205.2, R206.2, R207.2, R210.2, R211.2, R212.2, R213.2, R214.2, R215.2, R216.2, R217.2, R218.2, R219.2, R220.2, R221.2, R222.2, R223.2, R224.2, R225.2, R226.2, R227.2, R228.2, R229.2, R230.2, R231.2, R232.2, R233.2, R234.2, R235.2, R236.2, R237.2, U101.57, U201.2, U201.11, U201.12, U201.13, U202.2, U202.3, U202.8, U202.9, U203.8, U203.9, U204.4
ILLUM_STROBE: R109.1, U101.36
IO_ENABLE_LINK: JP201.2, R201.1
ISO_GATE: Q201.1, R201.2, R202.1
RF_ANT: AE101.1, C107.1, L101.2
RF_SIP: C106.1, L101.1, U101.1
SCCB_ENABLE_LINK: JP202.2, R204.1
SCCB_EN_SAFE: R204.2, R205.1, U204.5
SENS_D0: R224.1, U201.21
SENS_D1: R225.1, U201.20
SENS_D2: R226.1, U201.19
SENS_D3: R227.1, U201.18
SENS_D4: R228.1, U201.17
SENS_D5: R229.1, U201.16
SENS_D6: R230.1, U201.15
SENS_D7: R231.1, U201.14
SENS_EXTCLK: R235.1, U203.13
SENS_HREF: R234.1, U202.11
SENS_PCLK: R232.1, U202.13
SENS_SCL: R242.1, U204.2
SENS_SDA: R243.1, U204.3
SENS_TRIG_IN: R237.1, U203.11
SENS_VIO_1V8: C202.1, C204.1, C206.1, C208.1, R242.2, R243.2, U201.23, U201.24, U202.16, U203.16, U204.1
SENS_VSYNC: R233.1, U202.12
SENS_XSHUTDN_N: R236.1, U203.12
STRAP_GPIO3: R103.1, U101.8
STRAP_GPIO45: R104.1, U101.51
STRAP_GPIO46: R105.1, U101.52
UNUSED_A_INPUT: R207.1, U203.7
UNUSED_B_INPUT: R206.1, U202.10
USB_DM_MCU: R113.2, U101.25
USB_DP_MCU: R112.2, U101.26
USB_EN1: J107.1, U101.24
USB_EN2: J107.2, U101.27
