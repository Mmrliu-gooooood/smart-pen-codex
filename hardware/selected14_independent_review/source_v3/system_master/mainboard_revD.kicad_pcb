# Repository Mmrliu-gooooood/smart-pen-codex (continued)

## KiCad design hardware/power14_single_feed_revB/power_integrated_study.kicad_pcb (continued)

Parts:
C101, C102, C103, C104, C105, C106: 100nF 16V; C_0603_1608Metric
C107: 4.7uF / effective0.1..10uF TBD; C_0805_2012Metric
J104: CELL NTC2 TWO WIRES; WireLands_2_P2.5_AssemblyUnqualified
R101: 200R 0.1% / total0.2%; R_0805_2012Metric
R102, R104, R109: 10k 0.1% / total0.2%; R_0805_2012Metric
R103: 34k 0.1% / total0.2%; R_0805_2012Metric
R105, R114: 100k 1%; R_0603_1608Metric
R106, R107: 1M 1%; R_0603_1608Metric
R110: 110k 0.1% / total0.2%; R_0805_2012Metric
R111, R113: 100k 0.1% / total0.2%; R_0805_2012Metric
R112: 255k 0.1% / total0.2%; R_0805_2012Metric
RT101: NTCLE100E3103GB0
U101: TPS3808G25DBVR; TI_DBV0006A_OfficialDerived_NOFAB
U102: TPS3899DL01DSER; TI_DSE0006A_SMDleft_ExposedDerived_NOFAB
U103, U104: TMUX1101DCKR; TI_DCK0005A_OfficialDerived_NOFAB
U105: TPS3700DDCR; TI_DDC0006A_OfficialDerived_NOFAB
U106: REF3425IDBVR; TI_DBV0006A_OfficialDerived_NOFAB

Connections:
/thermal/CE_MID: U103.1 (D), U104.2 (S)
/thermal/COLD_SENSE: R112.2, R113.1, U105.4 (INB-)
/thermal/HOT_SENSE: R110.2, R111.1, U105.3 (INA+)
/thermal/NTC_NODE: J104.1, R109.2, R110.1, R112.1, RT101.1
/thermal/REF_EXC: C107.1, R101.1, R103.1, R109.1, U106.5 (OUT_S), U106.6 (OUT_F)
/thermal/REF_SENSE_FAST: R103.2, R104.1, U102.5 (SENSE)
/thermal/REF_SENSE_SLOW: R101.2, R102.1, U101.5 (SENSE)
/thermal/REF_VALID: R105.2, R106.1, U101.1 (RESET_N), U102.6 (RESET_N), U104.4 (SEL)
/thermal/THERM_OK: R107.1, R114.2, U103.4 (SEL), U105.1 (OUTA), U105.6 (OUTB)
CE_PERMISSION_INTERNAL: U103.2 (S); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, J104.2, R102.2, R104.2, R106.2, R107.2, R111.2, R113.2, RT101.2, U101.2 (GND), U102.3 (GND), U103.3 (GND), U104.1 (D), U104.3 (GND), U105.2 (GND), U106.1 (GND_F), U106.2 (GND_S); also elsewhere on the board
VBUS_5V: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, R105.1, R114.1, U101.3 (MR_N), U101.6 (VDD), U102.4 (VDD), U103.5 (VDD), U104.5 (VDD), U105.5 (VDD), U106.3 (EN), U106.4 (IN); also elsewhere on the board

Notes on the sheet:
CE dual-SPST logic interlock candidate / NEW-REF-P0 / NOFAB
SYSTEM-P0: thermal R8 / JP1 removed; CORE JP1 is sole OPEN commissioning gate.
U101 CT deliberately open: 12-28ms release delay. U102 CTS/CTR open: conditional 50us max fault detect.
REF2.5V / conditional safety2.34-2.53V. 20-30C static permission tested; thermal lag and transients NOT approved.
LAYOUT STUDY ONLY: two real offboard NTCs, no charge/fabrication approval.
RT101 = OFFBOARD CELL NTC #2 / NOT PCB-MOUNTED BOM retained; independent two wires via J104. No pack qualification or thermal-bond approval.

Board: 4 copper layers, 14.0 x 45.0 mm, 50 parts (26 on the bottom side), 25 nets.

## KiCad design hardware/usb_tail_revB/usb_tail_revA.kicad_pcb

File hardware/README.md:

# 当前硬件入口（19项未连接）

[mainboard_wip19_20261102](mainboard_wip19_20261102/README.md) 是当前f763基线：0错误/0警告/19项未连接/0网表差异，仍NOFAB / NO POWER。下面617a／23项及更早入口均为历史快照；不得混搭其规则/模型/审查依赖。

---

# 历史硬件入口（617a／23项）

[mainboard_wip_20261102](mainboard_wip_20261102/README.md) 是历史有限静态主板工作基线，实际 **0违规 / 23未连接 / 0网表差异**。完整原生项目、预览、父板及检查脚本均有入口。仍未完成主板连线、整笔装配、SI/PDN和制造验证，**NOFAB / NO POWER**。

下列2026-10-28记录仅属历史模块状态；其中“无整笔主板PCB”等表述不再描述当前进度，旧模块报告不被改写或冒充新检查。

---

# 硬件工程状态（2026-10-28）

**未完成整机设计；禁止据当前版本直接投产或接入锂电池试充。**

本目录将按模块持续提交可编辑源文件、生成脚本和新验证记录。2026-10-27 尚未提交的硬件工作副本目前无法恢复，因此后续标记 `rebuild-20261028` 的文件是重新构建、重新验证的版本，不是原件恢复，也不继承旧版本检查结果。

## 交付分界

| 模块 | 当前仓库状态 | 制造限制 |
|---|---|---|
| MCU / USB-C | [重建评审版源文件](mcu_usb/README.md)，新 ERC 与网表检查通过 | 无整笔主板 PCB、天线定型或 RF 验证 |
| 充电 / 升降压电源 | [重建评审版源文件](../docs/electronics/power_core.md)，新 ERC 与网表检查通过 | 电芯、保护、NTC、充电热安全未定型 |
| 拿起唤醒 / 二值落笔 | [原理图与 12×20 mm PCB](pickup_contact/README.md)，新 ERC/DRC 与网表检查通过 | 新版本未通过实物验证 |
| 摄像头接口 / 电平转换 | 整合未完成 | 模组控制脚映射、低 PCLK 配置和上电顺序须闭环 |

旧工作记录中提到的 ERC/DRC 通过，不是本目录新文件的验证证据。以每个模块带日期、命令和文件哈希的报告为准。子模块 ERC/DRC 不能替代整机网表、装配、电源、射频或真实书写测试。

## 制造放行前仍需完成

- 光学近焦、点阵尺寸、倾角、短曝光与原始图像验证，确定镜头和板型。
- 模组真实引脚、电平、复位/关断映射及采样时序核对。
- 主板布局布线、回流路径、USB/RF/高速 DVP、电池和机械公差联合审核。
- 电池数据表、保护阈值、NTC 接触与断短路安全、USB 取电模式和温升验证。
- 实际落笔、拿起唤醒、离线补传、无线、升级、低功耗和故障恢复测试。
- 两支样机完整报价核算，不能把目标预算当作已获得的报价。

参见 [整体放行门槛](../docs/system/RELEASE_GATES.md) 和 [摄像头资料结论](../docs/optics/SC035HGS_DOCUMENT_REVIEW.md)。

## 重建版的使用限制

MCU 引脚分配以新提交的 `mcu_usb/gpio_assignment.json` 为准，不保证与遗失工作副本或旧程序相同。既有合成 BLE 测试固件不是本硬件的完整驱动，摄像头固件、隔离控制、上电时序尚未联调，不可直接套用旧引脚表。

本次三模块独立审阅见 [检查报告](../docs/verification/ELECTRICAL_REVIEW_20261028.md)。跨模块名称核对不等于物理集成，见 [接口约束](../docs/electronics/integration_contract.md)。

## 摄像头资料依据更新（2026-10-28）

旧30针订购表不是实物已验证线序，后续接口不锁死该表。摄像头逻辑接口仍未制造放行；不等待厂家无法提供的新资料，先使用既有PDF、原厂参考与公开代码推进。见[PDF页码索引](../docs/research/pdf_page_index.md)、[线序/厂家声明证据](../docs/research/custom_pin_evidence.md)及[驱动核对](../docs/research/public_driver_evidence.md)。这次只更新设计依据，不改变已有三模块原理图/PCB，不声称新增相机电气验证。

## 新增电路（2026-10-28 后续设计）

- [独立补光驱动](../docs/electronics/illumination_driver.md)：新增原理图、默认开路调试桥、MOS控制和串联电阻限流；没有PCB或光学安全放行。
- [相机电源门控](../docs/electronics/power_safety.md)：新增原理图、默认OFF与物理开路负载隔离；不是限流/反灌保护器，不能连接未知模组。

这些是新绘制并检查的电路，不代表相机接口、整机主板或实物联调已经完成。

- [相机隔离与电平转换](../docs/electronics/camera_isolation.md)：新增三子页元件级电路，固定方向DVP、SCCB转换及默认断开控制；仍无相机PCB，不能按旧30针表直接接。新三个模块的[独立审阅](../docs/verification/NEW_ELECTRICAL_REVIEW_20261028.md)不替代带载电平、时钟和相机实测。

Parts:
D101: TPD1E10B06DYAR; TI_DYA0002A_SOD523_OfficialLandpattern
J101: USB4105-GF-A-120; USB4105_GroundHeelTrim80um_AssemblyUnqualified
R110, R111: 5.1k 1%; R_0603_1608Metric
TP101: USB_DP_INTERNAL_WIRE; WireLand_1.5x2_NoPaste
TP102: USB_DM_INTERNAL_WIRE; WireLand_1.5x2_NoPaste
TP103: VBUS_5V_INTERNAL_WIRE; WireLand_1.5x2_NoPaste
TP104: GND_INTERNAL_WIRE; WireLand_1.5x2_NoPaste
U102: TPD4E05U06DQAR; TI_DQA0010A_USON10_OfficialLandpattern

Connections:
GND: D101.2 (GND), J101.A1 (GND), J101.A12 (GND), J101.B1 (GND), J101.B12 (GND), J101.S1 (SHIELD), R110.2, R111.2, TP104.1, U102.3 (GND), U102.8 (GND)
USB_CC1: J101.A5 (CC1), R110.1, U102.4 (D2+), U102.7 (NC_ROUTE)
USB_CC2: J101.B5 (CC2), R111.1, U102.5 (D2-), U102.6 (NC_ROUTE)
USB_DM: J101.A7 (D-), J101.B7 (D-), TP102.1, U102.2 (D1-), U102.9 (NC_ROUTE)
USB_DP: J101.A6 (D+), J101.B6 (D+), TP101.1, U102.1 (D1+), U102.10 (NC_ROUTE)
VBUS_5V: D101.1 (IO), J101.A4 (VBUS), J101.A9 (VBUS), J101.B4 (VBUS), J101.B9 (VBUS), TP103.1

Notes on the sheet:
USB TAIL RevA / NO FAB. R112/R113 remain on mainboard. No PD/current advertisement detection.
U102 NC 6/7/9/10 are optional straight-through PCB pads per TI; no internal chip connection assumed.
Wire lands are real assembly interfaces requiring harness/strain relief qualification, NOT completed pen interconnects.
J101 shell is grounded at all four S1 pads. Keep VBUS TVS/ESD ground paths short. USB100 default policy unchanged.

Board: 4 copper layers, 12.0 x 20.0 mm, 9 parts (0 on the bottom side), 6 nets.

File hardware/usb_tail_revA/bom_candidates.csv:

ref,value,footprint,assembly_status
D101,TPD1E10B06DYAR,SmartPen:TI_DYA0002A_SOD523_OfficialLandpattern,candidate no procurement
J101,USB4105-GF-A-120,Connector_USB:USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,candidate no procurement
R110,5.1k 1%,Resistor_SMD:R_0603_1608Metric,candidate no procurement
R111,5.1k 1%,Resistor_SMD:R_0603_1608Metric,candidate no procurement
TP101,USB_DP_INTERNAL_WIRE,SmartPen:WireLand_1.5x2_NoPaste,wire interface requires harness/strain relief
TP102,USB_DM_INTERNAL_WIRE,SmartPen:WireLand_1.5x2_NoPaste,wire interface requires harness/strain relief
TP103,VBUS_5V_INTERNAL_WIRE,SmartPen:WireLand_1.5x2_NoPaste,wire interface requires harness/strain relief
TP104,GND_INTERNAL_WIRE,SmartPen:WireLand_1.5x2_NoPaste,wire interface requires harness/strain relief
U102,TPD4E05U06DQAR,SmartPen:TI_DQA0010A_USON10_OfficialLandpattern,candidate no procurement

## KiCad design hardware/illumination_layout_candidate/illumination_NOFAB.kicad_pcb

File hardware/illumination_layout_candidate/README.md:

# 独立照明驱动 PCB 研究 — 8 × 15 mm / NOFAB

2026-10-28。真实原生可编辑原理图与已布线 PCB，不是整笔完成或生产许可。**330 Ω 串联电阻硬限流 + PMV30UN2 低边开关，不是恒流源。** 不修改已冻结 illumination_driver 或电源14×45目录；仅为旧照明电路赋予实际焊盘接口并布局。

## 当前检查

- 7 个实体 / 16 个端点 / 7 网；4 个板上电子器件（3 电阻 + Q1）、2 个焊线接口、1 个真实 OPEN / DNP commissioning 桥。
- 新原生 ERC 0，PCB DRC 0、未连接0、原理图 parity0，无新豁免。
- 原 XML 全端点/值/DNP 对比无电气变化；独立手写合同检查实际16焊盘网络与Q1的1=G/2=S/3=D；真实 pad/trace/via/填铜接触图7/7网连通。
- 源差量仅 J1/J2/JP1 footprint 分配；Q1继续原SOT23库候选。`source_projection_contract.json`列明。不得把“Q1原厂引脚已核”说成“原厂完整landpattern逐几何已核”。

## 结构、语义接口、回流

板框 **8 × 15 mm，标称0.8 mm，2层，单面装配**。不是已经证明可以另塞一块板的整笔机械批准。J1/J2 为1.4 × 2.0 mm铜焊线地，2.5 mm节距，只有铜和阻焊，无钢网开口；不是已经选中的连接器或已验证的拉力结构。

- **J1：1=3V3_AON（仅3.0–3.6 V稳压），2=保护后GND，3=ILLUM_STROBE（现MCU GPIO48，3.3 V）。** 不可接电池/USB5V。
- **J2：1=LED_A，2=LED_K。** 只接一颗无内置驱动的独立LED的阳极/阴极。LED_K不是GND，不能自行并到外壳地或相机端口。未知相机30pin的25/26不得接入；本板没有假定它们的映射、电平或模块LED驱动。
- LED外线应为靠近的A/K二线对：J1.1→JP1→R1→J2.1→外部LED→J2.2→Q1.D→Q1.S→GND。电源与返回也应成对回host，禁止从触点/NTC信号地借回流。
- 板上LED电流线宽0.25 mm，栅极/控制0.20 mm；两颗0.6/0.3 mm GND过孔把源极回流与host GND接到真实B面连续填铜。B面不是凭网名自动算连通。
- 线材外径、剥线长度、焊料隆起、弯曲半径、绝缘套和应力释放**未选择/未检验**。不能仅用0.8 mm PCB+器件高度当装配包络。Q1官方文字表给SOT23本体高度0.9–1.1 mm；按1.1+0.8+假设焊接0.15约2.05 mm仅是条件扫描值，不涵盖电阻、线束和外壳公差。

`preview/assembly.svg`直接读取实际native位置/铜，明确front及back X-ray非镜像，给出全部pad编号和J1/J2线序。它不是光学头CAD，也不包含未知鼻端LED。

## 默认禁止与限流边界

JP1保持真实DNP和物理开路。未完成LED选型、短曝光亮度和光安全资格，禁止桥接。OPEN时切断LED供电；仅在人工commission后，GPIO高可使Q1导通，低/高阻由100 kΩ栅极下拉。关断不是理想零漏光；上电斜率、Miller耦合、GPIO模式切换、线束振铃及最短脉宽必须台架验证。没有加入未审查的电容/驱动器，也不把芯片1.8 V LEDSTROBE输出直接并联GPIO48。

假定3V3≤3.6 V且**实装R1始终≥326.7 Ω**（330 Ω的初始±1%，全温还需具体料号TCR/老化/降额）:

- LED短路/Vf=0时上界 **11.0193 mA**，R1≤**39.6695 mW**。这不是正常发光电流；正常由`(Vrail−Vf−VDS)/R1`决定，未知LED亮度可能完全不够短曝光。
- 静态MOS在线性区最坏负载线功耗上界`Vrail²/(4Rmin)`约**9.9174 mW**（非负被动LED压降、没有旁路）。仅静态数学上界，未计开关损耗/栅电荷/热阻与动态波形，不代替热验证。
- Q1或LED短路仍受R1约束；**R1短路或接线绕过R1不受此保护**，不称单故障安全。不得为亮度擅改电阻/升压。
- R1要求实装温度降额后至少承受此功耗；当前原值≥0.1 W，具体电阻MPN仍未批准。用额定0.1 W除以39.7 mW不是封闭笔壳热认证。
- 任何可见/近红外LED都不能仅凭这个电流上界推断眼安全；没有光学辐照/短曝光坐标精度合格声明。

## 官方核对与精确封装限制

[Nexperia PMV30UN2官方资料](https://assets.nexperia.com/documents/data-sheet/PMV30UN2.pdf)，2014-04-24，Table2确认G/S/D，Table7包含低栅压规格，p10 SOT23/TO-236AB本体/脚距，p11有推荐reflow焊盘。
当前采用本机KiCad `Package_TO_SOT_SMD:SOT-23`：pads1/2中心(-0.9375,±0.95)、pad3中心(+0.9375,0)，铜1.475×0.6 mm；本体F.Fab及实际pad数/序已核。但**没有声称与官方p11逐铜/阻焊/钢网一致**：官方PDF文字可读，直接下载被HTTP403拒绝后停止，未换路绕过；web截图未交付可查看图片。精确官方landpattern及装配工艺需后续取得可读图再核。不能把库默认形状当厂家批准。

官方490 mW/1000 mW热额定对应指定测试PCB，不能套用为本8×15板的热能力。PMV30UN2具体订货/包装/库存/价格未询价。电阻与线束成本未构成最终BOM。

## 复现

`run_checks.sh`只核最终源。设计构建顺序为 `tools/project_source.py` → 原生XML导出 → `tools/build_board.py` → `tools/route.py`；构建会重置此候选PCB，不要在人工改动上误运行。独立检查为 `check_design.py`、`check_copper_graph.py`。不发布原厂PDF，不输出生产Gerber；所有检查仅支持此候选连接正确性。

Parts:
J1: HOST INTERNAL / MPN TBD; WireLands_3_P2.5_AssemblyUnqualified
J2: LED A/K ONLY / MPN TBD; WireLands_2_P2.5_AssemblyUnqualified
JP1: OPEN DNP / COMMISSION ONLY; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm; not fitted
Q1: PMV30UN2; SOT-23
R1: 330R 1% >=0.1W; R_0603_1608Metric
R2: 1k 1%; R_0603_1608Metric
R3: 100k 1%; R_0603_1608Metric

Connections:
/3V3_AON: J1.1, JP1.1 (A)
/GND: J1.2, Q1.2 (S), R3.2
/ILLUM_STROBE: J1.3, R2.1
/LED_A: J2.1, R1.2
/LED_COMMISSIONED: JP1.2 (B), R1.1
/LED_GATE: Q1.1 (G), R2.2, R3.1
/LED_K: J2.2, Q1.3 (D)

Notes on the sheet:
2026-10-28 新增照明限流 / NO FAB
独立LED端口，不是未知相机30pin连接器。JP1开路/DNP；先选光源并审查，再人工commission。
3.0-3.6V regulated only. NO direct battery / VBUS. GPIO48 only; no extra GPIO.
R1硬限流候选：3.6V、Rmin326.7R、LED短路时 <=11.02mA / <=39.67mW。
不是恒流源，也不是光安全批准。光谱/辐射功率/视场/眼安全/LED额定尚未确定。
复位/控制断开靠R3关断；瞬态栅耦合、上电和PWM脉宽仍需示波器测试。
LEDSTROBE芯片1.8V与MCU GPIO48不得直接并联；本页只接受MCU侧语义输入。

Board: 2 copper layers, 8.0 x 15.0 mm, 7 parts (0 on the bottom side), 7 nets.

File hardware/illumination_layout_candidate/bom_candidates.csv:

Ref,Value,MPN_candidate,Footprint,DNP,Qualification
J1,HOST INTERNAL / MPN TBD,PCB feature; no purchased connector selected,SmartPenIllum:WireLands_3_P2.5_AssemblyUnqualified,False,NOFAB; quote/assembly/TCR/optical qualification pending
J2,LED A/K ONLY / MPN TBD,PCB feature; no purchased connector selected,SmartPenIllum:WireLands_2_P2.5_AssemblyUnqualified,False,NOFAB; quote/assembly/TCR/optical qualification pending
JP1,OPEN DNP / COMMISSION ONLY,PCB feature; no purchased connector selected,Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm,True,NOFAB; quote/assembly/TCR/optical qualification pending
Q1,PMV30UN2,PMV30UN2,Package_TO_SOT_SMD:SOT-23,False,NOFAB; quote/assembly/TCR/optical qualification pending
R1,330R 1% >=0.1W,TBD resistor exact MPN,Resistor_SMD:R_0603_1608Metric,False,NOFAB; quote/assembly/TCR/optical qualification pending
R2,1k 1%,TBD resistor exact MPN,Resistor_SMD:R_0603_1608Metric,False,NOFAB; quote/assembly/TCR/optical qualification pending
R3,100k 1%,TBD resistor exact MPN,Resistor_SMD:R_0603_1608Metric,False,NOFAB; quote/assembly/TCR/optical qualification pending
