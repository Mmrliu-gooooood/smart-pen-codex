# Repository Mmrliu-gooooood/smart-pen-codex

File README.md:

> 最新研究阶段：[2026-11-07进度](docs/progress/2026-11-07.md)与[隔离源码/验证边界](research/2026-11-07_reviewed_stage/README.md)。HOLD / NOFAB / NOPOWER。下面保留原11月3日工程入口作为历史快照，当前状态以[CURRENT_STATUS](CURRENT_STATUS.md)为准。

## 当前设计入口（2026-11-03）

当前主板工作版 **a51a57 / 13项未连接 / 0项DRC违规**。请先读 [当前状态](CURRENT_STATUS.md) 与 [阶段进度材料](docs/progress/2026-11-03.md)，再打开 [原生工程](hardware/mainboard_wip13_20261103/README.md)。所有成果仍为 **NOFAB / NO POWER**。阶段记录和仓库推送不等于最终任务完成。

---

# 智点笔 / Smart Pen

纸上出墨、笔尖近摄、板端坐标解码、BLE 与离线补传的两支工程样机项目。

**当前状态：开发中，禁止据本仓库直接投产。** 目标是可制作并经样机验证的整机，不把电路子页、概念外形或软件单元测试当作完整交付。尚无整机通过光学、功耗、热、安全、书写精度或可靠性实测的证据。制造发布须满足 [放行门槛](docs/system/RELEASE_GATES.md)。

**2026-10-29 阶段备份：请先读 [当前选用版本与未完成项](CURRENT_STATUS.md)。** 新备份保留了失败版本、独立审查和修订记录；旧目录名称或某一子板的零错误报告不代表整笔通过。该历史快照记录 **17 项完整 DRC finding、38 处未连接、4 项真实短路 finding**；它不是当前基线。当前状态以上方入口为准，仍禁止直接下单打板。

硬件进度与交付限制请看 [硬件状态](hardware/README.md)。当前正在重建并分模块提交硬件评审文件，尚非整机打板包。

## 已确认约束（2026-10-27）

- 单支 ≤ ¥380，两支 ≤ ¥760，包含摄像头/镜头、全部电子件、电池、刚柔 PCB、贴片焊接、外壳及笔芯；不含运费。开发工具和返工支出另列且须确认，不能静默突破上限。
- 优先级：坐标准确与安全 > 体积（目标直径 15–18 mm）> 续航。4 小时连续书写、1000 小时待机仅为优化目标，不是硬验收。
- 先黑点白纸，最终红外方案；允许重新生成密集点阵。不得假称兼容 Anoto 或现有纸张。
- 可换出墨笔芯，二值落笔检测，拿起预唤醒，短抬笔就绪，长闲置低功耗。
- 独立解码、BLE、断电安全离线坐标记录/确认补传、升级功能、USB-C 充电与烧录。
- 复用书台 Windows/网页上层功能，仅新增笔数据源。不重做评分、AI 或画画猜猜，不开发独立手机 App。
- 离线 24 小时有效书写作为估算起点，以成本和实际记录率优化，不能未经核算宣称满足。
- 每块板 < 100 × 100 mm。首轮 3D 打印，面向成人验证；儿童使用及销售须另行安全与法规评估。
- 首版样机目标不晚于 2026-11-26。用户配合采购、组装、采图、功耗与书写测试。远程工程文件不等于实体样机完成。

## 来源

书台源码基线：[digital_pen @ 0f8b569](https://github.com/Mmrliu-gooooood/digital_pen/tree/0f8b569176c77dad34aaf83bb008eb118c9f1208)。本项目不改动原仓库。
上传的 SC035HGS Rev D 是独立接口原型，仅作参考；其相机控制电平、模组连接与最终笔用光学尚待验证。

## 目录

- `docs/system/`：需求、风险、计划、制造放行证据。
- `docs/optics/`, `procurement/`：器件对比、报价条件及光学实验。
- `hardware/`, `docs/electronics/`：原理图、PCB、BOM、规则与电源预算。
- `mechanical/`, `docs/mechanical/`：参数化模型、装配与试验夹具。
- `firmware/`, `software/`, `tests/`, `docs/software/`：嵌入式核心、Windows 桥接与验证。

各子目录的状态说明具有约束力。标为候选、夹具、未布线、未实测的文件不能替代最终整机。

## 小视场软件实验进展

新增 [Gray8 ROI获取/网格搜索/严格解码](docs/software/roi_vision.md)，不再仅靠已对齐的合成cell输入。它输出窗口原点而非物理笔尖；当前仅合成变换测试，真实相机RAW、目标MCU性能和整机书写均未验收。

独立下一版 [ROI工作区/warm-start候选](docs/software/roi_vision_candidate.md) 保留参考实现，新增无每帧heap分配与有限非均匀尺度获取，并通过真实S3 SDK编译；仍不是握笔透视/实物实时性验收。

## KiCad design hardware/selected14_independent_review/source_v3/system_master/mainboard_revD.kicad_pcb

File hardware/selected14_independent_review/source_v3/README.md:

# Option B selected — v3 system/source allocation and passive fixture candidate

**Decision:** prototype recovery uses the existing mainboard J108 EN/BOOT/GND service points plus an external passive recovery fixture, replacing the two proposed internal buttons. This new version does not modify v2 or the earlier concept freeze. It changes source ownership, not PCB geometry/copper. Selection is not assembly or safety qualification.

## Stable source switch point

Open only the top-level `mainboard_revD.kicad_sch` in the selected folder (nested source-library/archive files are not alternate top-level projects):

|Source|Entities / endpoints|Top-level schematic SHA256|
|---|---:|---|
|`system_master/`|93 /383|`1f744f9490a27f5da831fb1936ebeb8cf0d84dc675fad8c475144963dad5dae5`|
|`mainboard_projection/`|83 /303|`c2687211f6085fb0a4ca409a26983ed62a124c91ae4243455eccdd9a72bf6854`|
|`fixture_projection/`|3 /7|`848aa5b0da7a69d56f48cef667227946e8b9d0e0d0bcdf490537f8297dd7aa31`|

`source_versions.json` locks all native source files. The system retains every original380 endpoint/net identity; the only new endpoints are JF1.1 CHIP_EN, JF1.2 BOOT_N, JF1.3 GND. SW101/SW102 preserve original reference, value, symbol UUID and pin identities, but their instances now truly reside on the `recovery_fixture` sheet. Original MCU switch-connected stubs are removed explicitly. This is recorded in `design_change.json`, not an on-board flag change used to hide missing parts.

The mainboard keeps actual J108 and J109, AE101.2 NC and C106/C107 native0402+DNP. All other retained source value/footprint/library/sheet/UUID/properties remain unchanged. The fixture projection contains SW101 RESET, SW102 BOOT and the JF1 mating interface, all as real source components with presently unselected physical parts/footprints.

## Actual per-board status, not mathematical parity clearance

Fresh native ERC: system master0; fixture0; main projection exits5 with only the pre-existing singleton VBUS_5V boundary warning, zero errors. Normal and optimized identity/ownership checks pass, rejecting duplicated switch ownership, hidden sensor handoff, missing switch and added active driver.

Expected unplaced mainboard functions now comprise **J103/J104/J105/J202** only. This must be verified by pairing the selected projection with the actual routed PCB and running full native DRC/parity; this source task does not run or claim that PCB result. The complete system still contains the externally allocated fixture and tail components. Moving switches does not make an unfinished fixture physical hardware.

- J103 retains pickup/contact6-net interface:3V3_AON/GND/AON_I2C_SCL/AON_I2C_SDA/PICKUP_INT_N/NIB_CONTACT_N.
- J104 retains camera-off-only UART sharing CAM_RESET_UART_TX/CAM_PWDN_UART_RX/GND; no concurrent sensor drive.
- J105 retains BATTERY_ADC/GND with ADC input safety requirements.
- J202 remains `SENSOR_1V8_SEMANTIC_NOT_FPC`: required physical sensor handoff unresolved, not an approved18-pin connector or permission to eliminate those connections.

## Ownership and cost

`system_ownership.json` has95 uniquely owned entities:83 mainboard,9 selected tailRevB,3 shared fixture. SW101 and SW102 each appear **once**, exclusively fixture-owned. The two internal semantic connector entities are not physical BOM parts. Tail components use the previously checked selected RevB source rather than duplicate old generic master parts.

Fixture procurement lines are SW101, SW102 and JF1; switch/probe MPNs, footprints, jig, wire, enclosure/strain relief and ESD protection remain unqualified and are not bought. A **single shared fixture cost is separately unquoted**, not counted once per pen and not used to claim either pen fits380RMB or the two-pen760RMB ceiling. Its mechanical/assembly/test cost must be budgeted explicitly before procurement. DNP and source BOM-exclusion flags are preserved.

## Passive fixture implementation contract

`fixture_handoff_contract.json` fixes J108↔JF1 by both source version and signal identity:
- pin1 CHIP_EN: SW101 can only short it toGND;
- pin2 BOOT_N: SW102 can only short it toGND;
- pin3 GND: first-make/last-break reference, currently a requirement—not a proven mechanical feature.

No external supply, push-pull driver, charger CE permission or camera signal is added. Reference pad coordinates in the contract are from the captured prelayout board and are **not** a final mechanical mating drawing. Any pad move, width/layout change affecting fixture access or face/orientation change requires a new geometry contract. Equal pin numbers do not establish a physically safe mating orientation.

Before any power: verify versions, source-to-contact continuity, switch-open state, alignment and absence of shorts in a qualified ESD-controlled setup. Connect ground before signals, disconnect it last. If this order cannot be mechanically guaranteed, do not hot-mate; connect unpowered and validate the complete setup first. The fixture itself supplies no power; only the separately qualified pen power path may be used. Keep unknown camera disconnected and all charging commissioning bridges open.

For download-boot validation, GPIO0/BOOT must be low at reset release and GPIO46 must satisfy its low boot condition; EN/CHIP_PU low resets the MCU. The source preserves R10510k pulldown on U101.52/GPIO46, but reset/strap levels and timing require physical measurement. After strap sampling, release BOOT; for normal boot reset with BOOT released. USB recovery depends on actual tail/J109 data and ground continuity; UART recovery requires camera-off isolation. No flashing, erase, eFuse change, charging or physical hardware operation has been performed here.

Espressif's source basis: [boot-mode selection](https://docs.espressif.com/projects/esptool/en/latest/esp32s3/advanced-topics/boot-mode-selection.html), [schematic checklist](https://docs.espressif.com/projects/esp-hardware-design-guidelines/en/latest/esp32s3/schematic-checklist.html). Fixture ESD, contact resistance/bounce, clamp/keying, timing, reset efficacy and recovery across bad firmware remain verification gates.

## Rebuild boundary

`tools/build_v3.py` verifies the frozen v2 input manifest and refuses to overwrite an existing v3. It creates native system/main/fixture sources only; no PCB or copper is written. `tools/verify_v3.py` checks the captured exported native maps and exact allocation. Fresh native exports/ERC are recorded per folder. A later source change requires a new version and the same checks. Final routed-board and fixture hardware checks remain independent; these source results are not manufacturing release files.

Board: 6 copper layers, 14.0 x 101.5 mm, 79 parts (3 on the bottom side), 59 nets.

Parts:
AE101: 2450AT18A0100001E_STUDY_NOFAB; Johanson_2450AT18A0100001E_Rev4_Study_NOFAB
C101: 1u; C_0603_1608Metric
C102: 22u; C_0603_1608Metric
C103, C104, C105: 100n; C_0603_1608Metric
C106, C107: DNP RF_TUNE; C_0402_1005Metric
C201, C202, C203, C204, C205, C206, C207, C208: 100n X7R; C_0603_1608Metric
J106: POWER_CORE; PowerWireLands3_KeyGap_NOFAB
J107: CHARGER_MODE; ModeWireLands3_KeyGap_NOFAB
J108: SERVICE_EN_BOOT_GND; ServiceProbe3_NOFAB
J109: USB_TAIL_LINK; USBWireLands3_14mm_PRELAYOUT
JP201: DNP_IO_COMMISSION; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP202: DNP_SCCB_COMMISSION; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L101: RF_MATCH_TBD; L_0402_1005Metric
Q201: PMV30UN2; SOT-23
R101, R102, R103, R104, R105, R203, R206, R207: 10k 1%; R_0603_1608Metric
R106, R107, R108, R109, R202, R210, R211, R212, R213, R214, R215, R216, R218, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231, R232, R233, R234, R235, R237: 100k 1%; R_0603_1608Metric
R112, R113: 22R SI_TBD; R_0603_1608Metric
R201: 1k 1%; R_0603_1608Metric
R204: 100R 1%; R_0603_1608Metric
R205: 4.7k 1%; R_0603_1608Metric
R217: 100k 1%; R_0402_1005Metric
R236: 4.7k 1% RESET_CANDIDATE; R_0603_1608Metric
R240, R241, R242, R243: 10k 1% INITIAL_100kHz; R_0603_1608Metric
U101: ESP32-S3-PICO-1-N8R8; ESP32-S3-PICO-1_LGA57_7x7_P0.4_OfficialDerived_NOFAB
U201: SN74AXC8T245PWR; TSSOP-24_4.4x7.8mm_P0.65mm
U202, U203: SN74AXC4T245PWR; TSSOP-16_4.4x5mm_P0.65mm
U204: TCA9517DGKR; VSSOP-8_3x3mm_P0.65mm

Connections:
3V3_AON: C102.1, C103.1, C104.1, C105.1, C201.1, C203.1, C205.1, C207.1, J106.2, R101.2, R102.2, R103.2, R203.2, R240.2, R241.2, U101.2, U101.3, U101.20, U101.46, U101.55, U101.56, U201.1, U202.1, U203.1, U203.2, U203.3, U204.8
BOOT_N: J108.2, R102.1, U101.5
CAM_BUS_EN: JP202.1, R108.1, U101.37
CAM_D0: R210.1, U101.12, U201.3
CAM_D1: R211.1, U101.13, U201.4
CAM_D2: R212.1, U101.14, U201.5
CAM_D3: R213.1, U101.15, U201.6
CAM_D4: R214.1, U101.16, U201.7
CAM_D5: R215.1, U101.17, U201.8
CAM_D6: R216.1, U101.18, U201.9
CAM_D7: R217.1, U101.19, U201.10
CAM_HREF: R220.1, U101.23, U202.6
CAM_IO_EN: JP201.1, R107.1, U101.48
CAM_ISO_OE_N: Q201.3, R203.1, U201.22, U202.14, U202.15, U203.14, U203.15
CAM_PCLK: R218.1, U101.21, U202.4
CAM_PWDN_UART_RX: R223.1, U101.50, U203.6
CAM_PWR_EN: R106.1, U101.47
CAM_RESET_UART_TX: R222.1, U101.49, U203.5
CAM_SCL: R240.1, U101.44, U204.7
CAM_SDA: R241.1, U101.45, U204.6
CAM_VSYNC: R219.1, U101.22, U202.5
CAM_XCLK: R221.1, U101.43, U203.4
CHIP_EN: C101.1, J108.1, R101.1, U101.4
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, J106.3, J107.3, J108.3, J109.3, Q201.2, R104.2, R105.2, R106.2, R107.2, R108.2, R109.2, R202.2, R205.2, R206.2, R207.2, R210.2, R211.2, R212.2, R213.2, R214.2, R215.2, R216.2, R217.2, R218.2, R219.2, R220.2, R221.2, R222.2, R223.2, R224.2, R225.2, R226.2, R227.2, R228.2, R229.2, R230.2, R231.2, R232.2, R233.2, R234.2, R235.2, R236.2, R237.2, U101.57, U201.2, U201.11, U201.12, U201.13, U202.2, U202.3, U202.8, U202.9, U203.8, U203.9, U204.4
ILLUM_STROBE: R109.1, U101.36
IO_ENABLE_LINK: JP201.2, R201.1
ISO_GATE: Q201.1, R201.2, R202.1
RF_ANT: AE101.1, C107.1, L101.2
RF_SIP: C106.1, L101.1, U101.1
SCCB_ENABLE_LINK: JP202.2, R204.1
SCCB_EN_SAFE: R204.2, R205.1, U204.5
SENS_D0: R224.1, U201.21
SENS_D1: R225.1, U201.20
SENS_D2: R226.1, U201.19
SENS_D3: R227.1, U201.18
SENS_D4: R228.1, U201.17
SENS_D5: R229.1, U201.16
SENS_D6: R230.1, U201.15
SENS_D7: R231.1, U201.14
SENS_EXTCLK: R235.1, U203.13
SENS_HREF: R234.1, U202.11
SENS_PCLK: R232.1, U202.13
SENS_SCL: R242.1, U204.2
SENS_SDA: R243.1, U204.3
SENS_TRIG_IN: R237.1, U203.11
SENS_VIO_1V8: C202.1, C204.1, C206.1, C208.1, R242.2, R243.2, U201.23, U201.24, U202.16, U203.16, U204.1
SENS_VSYNC: R233.1, U202.12
SENS_XSHUTDN_N: R236.1, U203.12
STRAP_GPIO3: R103.1, U101.8
STRAP_GPIO45: R104.1, U101.51
STRAP_GPIO46: R105.1, U101.52
UNUSED_A_INPUT: R207.1, U203.7
UNUSED_B_INPUT: R206.1, U202.10
USB_DM: J109.2, R113.1
USB_DM_MCU: R113.2, U101.25
USB_DP: J109.1, R112.1
USB_DP_MCU: R112.2, U101.26
USB_EN1: J107.1, U101.24
USB_EN2: J107.2, U101.27

## KiCad design hardware/power14_single_feed_revB/power_integrated_study.kicad_pcb

File hardware/power14_single_feed_revB/README.md:

# Single-feed revision B: explicit finite-width copper gate

**NOFAB. JP1 remains OPEN/DNP. Independent review still required.**

Rev A (`../power14_single_feed_candidate`, PCB12818a…8f8b2ca) was **rejected**: although its centreline resistor model reported zero charging-current flow in thermal traces, two retained thermal vias physically touched the original charger trunk at three positive-area regions outside C1. The original42-file freeze is retained as failed evidence. That numerical result did not prove physical isolation.

## Revision B

Baseline: original frozen14×45 PCB `5c5764e7576c9461464c12da3531410e63ef4db32a28a67a5fa6125ef0b92014`.
Candidate: `94ced2bd4100ba6fd8d9a9af11f101cc091a4c112a1bb3c8bb5dec2b2dedcdbc`.

Exact `REVB_EXPECTED_DELTA.json` geometry whitelist:
- Removed26 added-thermal copper objects:7 F.Cu shortcut tracks,2 offending through vias at(7.9,5.875)/(7.5,6.425),17 now-unused In2.Cu branch segments.
- Added43 tracks:3 F.Cu tracks,0.30mm wide,5.571320mm total;40 B.Cu tracks,0.15mm wide,19.968250mm total. No new vias. Other tracks/vias are unchanged.
- F.Cu path: C1.1(7.75,4.80)→(7.75,3.75)→(10.15,3.75)→existing thermal via(11.65,5.25), mm. It goes above C1, rather than retaining core-touching annuli or adding a via in the capacitor pad.
- B.Cu bridge joins existing thermal branch to that remote feed. This is a longer detour around other nets, not claimed optimal/production-quality routing. The many small route bends and long path merit layout refinement.
- All original charger-core track/via objects, all footprints/pad identities/positions/netnames/values/DNP, schematic sources and board rules remain unchanged. Filled polygons were regenerated and may differ.

## What passed freshly

Run `bash run_single_feed_checks.sh`; normal/optimized checks use explicit failure exceptions where specified.

- KiCad9 native ERC0; DRC0, unconnected0, schematic-parity0, all with `--exit-code-violations`, actual process exit0.
- 25 multi-pad nets connected, including native polygon-based physical connectivity, individual actual zone islands and drilled-via annuli.
- The copied independent finite-width audit (`physical_contacts.py`, provenance: `docs/verification/power14_single_feed_review_20261028`) finds **all original-core↔added-thermal VBUS copper contacts confined to C1.1**. No extra contact outside that pad. Shape expansion uses0.5µm inward polygon approximation and explicit drill subtraction. This is stronger than the previous centreline model, but not a manufacturing-tolerance or electromagnetic field proof.
- Delta whitelist verifies 26 removals/43 additions, no original core copper removal and no common-item changes. JP1 still DNP, sources/rules unchanged.
- Original frozen104 file hashes remain unchanged.
- Normal versus Python `-O` physical-contact, DC-network and explicit delta outputs agree. This does not certify every inherited helper against all failure modes.

## Conditional DC comparison, not safety signoff

The independent resistor implementation, adapted to the candidate path, assumes85°C copper, outer31.5µm/inner18µm, ideal zero-ohm pads/vias and centreline splitting. It excludes finite pad spreading, return impedance, via barrel resistance, heating, noise and dynamic device models.

- Only BQ U1.13 normalized1A: max added-thermal flow6.96×10^-14A/A, numerical zero; original wide trunk trace drop9.478628mV/A. Original board gave0.322809852A/A unintended fine-trace flow and6.821066mV/A total drop.
- Only U102.4 hypothetical25mA:9.800580mV drop, versus original7.046764mV. The extra route costs supply resistance;25mA is not a confirmed IC worst-case load.
- KCL and power conservation pass.1A is not USB current authorization.
- Finite-width topology is checked separately before relying on this conditional transfer model. Exact finite-current distribution within C1 pad still needs a more detailed model/physical measurement.

This candidate does **not** fully convert the downstream network into a tree or widen every0.15mm thermal trace. Quiet/Kelvin returns, differential ground movement, reference/NTC leakage, contamination, ramp/brownout/charging/LED/RF transients, sensor thermal coupling and cell/assembly/manufacturing limits remain open. Supply drop cannot be subtracted directly from comparator differential recovery/cutoff margins. Do not close JP1.

## Publication and reproduction

Only `SINGLE_FEED_REVB_MANIFEST.json` is authoritative for current source and evidence. Other copied files, old README-derived manifests, reports and previews in this scratch directory are **not current evidence** and must not be recursively published. Earlier failed routing reports are retained but excluded from the current whitelist.

Dependencies: installed KiCad9, system pcbnew/numpy/scipy, `../power_core_layout_candidate/power_core_NOFAB.kicad_pcb`, and immutable `../power_integrated_layout_14x45/`. Current native files suffice for review; `make_single_feed.py` then `bridge_back_supply.py` regenerate geometry with fresh UUIDs, requiring a new independent delta whitelist rather than overwriting this freeze.

No purchase, power-up, charging, physical measurement, Gerber release or GitHub publication occurred.

Notes on the sheet:
LAYOUT STUDY ONLY: two real offboard NTCs, no charge/fabrication approval.

Parts:
C1: 2.2uF 16V; C_0805_2012Metric
C2, C3, C4: 10uF 10V; C_0805_2012Metric
C5, C6: 22uF 6.3V; C_0805_2012Metric
J1: NTC WIRES / MPN TBD; WireLands_2_P2.5_AssemblyUnqualified
J2: VBUS IN; WireLands_2_P2.5_AssemblyUnqualified
J3: 3V3 OUT; WireLands_2_P2.5_AssemblyUnqualified
J4: PROTECTED PACK ONLY; WireLands_2_P2.5_AssemblyUnqualified
J5: MCU USB MODE / NO CE PORT; WireLands_Mode3_KeyGap_NOFAB
JP1: OPEN / DO NOT BRIDGE; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm; not fitted
L1: XFL4015-471MEC 0.47uH; Coilcraft_XFL4015_Official_NOFAB
R1: 8.66k 1%; R_0603_1608Metric
R2: 3.24k 1%; R_0603_1608Metric
R3: 68k 1%; R_0603_1608Metric
R4, R5: 100k; R_0603_1608Metric
R6: 10k 1%; R_0603_1608Metric
R7: 511k 1%; R_0603_1608Metric
R8: 91k 1%; R_0603_1608Metric
RT102: NTCLE100E3103GB0 / OFFBOARD CANDIDATE
U1: BQ24074RGTR; TI_RGT0016B_Official_NOFAB
U2: TPS63802DLAR; TI_DLA0010A_Official_NOFAB

Connections:
/core/3V3_AON: C5.1, C6.1, J3.1, R7.1, U2.6 (VOUT)
/core/CHARGE_DISABLE: JP1.1 (A), R6.2, U1.4 (~CE)
/core/CHG_ILIM: R2.1, U1.12 (ILIM)
/core/CHG_ISET: R1.1, U1.16 (ISET)
/core/CHG_TMR: R3.1, U1.14 (TMR)
/core/PACK_NTC: J1.1, RT102.1, U1.1 (TS)
/core/PACK_PLUS_PROTECTED: C2.1, J4.1, U1.2 (BAT), U1.3 (BAT)
/core/REG_FB: R7.2, R8.1, U2.4 (FB)
/core/SW_L1: L1.1, U2.9 (L1)
/core/SW_L2: L1.2, U2.7 (L2)
/core/SYS_RAW: C3.1, C4.1, U1.10 (OUT), U1.11 (OUT), U2.1 (EN), U2.10 (VIN)
/core/USB_EN1: J5.1, R4.1, U1.6 (EN1)
/core/USB_EN2: J5.2, R5.1, U1.5 (EN2)
CE_PERMISSION_INTERNAL: JP1.2 (B); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.2, J2.2, J3.2, J4.2, J5.3, R1.2, R2.2, R3.2, R4.2, R5.2, R8.2, RT102.2, U1.8 (VSS), U1.17 (VSS), U2.2 (MODE), U2.3 (AGND), U2.8 (GND); also elsewhere on the board
VBUS_5V: C1.1, J2.1, R6.1, U1.13 (IN); also elsewhere on the board

Notes on the sheet:
2026-10-28 重建稿 / REBUILT - NO FAB - 禁止投板与连接未批准电池
不是原件恢复；本次重新生成与检查。JP1保持开路，充电默认禁用；已核IC landpattern；完整BOM、电池、NTC与热设计未放行。
1 电池电源路径 / POWER PATH
2 常供电升降压 / BUCK-BOOST
J1: 外接真实NTC两线接口，型号/温度窗口/连接器待定。
GND = 保护后PACK_MINUS；禁止连接裸CELL_MINUS绕过保护。
3 专用GPIO接口 / 调试充电跳线
USB_EN1 -> MCU GPIO18；USB_EN2 -> GPIO21；禁止复用UART。
复位默认LOW/LOW=USB100；休眠/枚举/来源授权仍需系统验证。
JP1为物理开路跳线，未批准电池/NTC前禁止短接。
R1=8.66k: 91.12-113.73mA；R2=3.24k: 最坏536.23mA。
R2不是500mA硬上限；CE支路电流也必须计入USB总电流。
511k/91k -> 3.3077V标称；纹波/偏置/负载阶跃尚未测试。
COUT有效容量与电感饱和/DCR需按实际器件和布局核验。
14x45mm PCB候选；有效C、热、制造与线束尚未批准。
RELEASE BLOCKERS / 未放行项目
仅验证过的5V输入；USB-C/ESD/OVP在外部。
VBUS_5V / 3V3_AON / USB_EN1 / USB_EN2为统一逻辑网名。
充电电压容差、NTC故障与温度边界、保护电池待验证。
CE内部约285k下拉：JP1开路也有VBUS偏置电流。
JP1改为外部安全许可串联开路；绝不是直接接地许可。
转换器低压能力不等于正常电池放电截止；策略待定。
本次ERC仅检查连接，不批准电池充电或生产。
RT102: OFFBOARD CELL NTC #1 via J1 Independent from RT101; protected GND only. Candidate part, pack mounting NOT qualified.
